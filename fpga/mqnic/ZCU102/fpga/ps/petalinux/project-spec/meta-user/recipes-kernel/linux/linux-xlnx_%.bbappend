SRC_URI += "file://enable_ptp.cfg \
            file://enable_auxiliary_bus.cfg \
            "

FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

